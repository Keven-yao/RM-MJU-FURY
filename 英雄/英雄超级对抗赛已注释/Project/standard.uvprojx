# Keil uVision project standard.uvprojx, settings and files
target standard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\User\AHRS;..\User\DSP\Include;..\User\FreeRTOS\include;..\User\FreeRTOS\portable;..\User\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\user_lib;..\user\hardware;..\user\hardware\delay;..\user\APP;..\user\DSP;..\user\APP;..\user\hardware;..\user\IMU
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_rng.c stm32f4xx_dma.c stm32f4xx_syscfg.c
  group freeRTOS
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../user/DSP/: crc.c judge.c
  group main
    ../user/: main.c
  group APP
    ../user/APP/: Chassis.c feedback.c gimbal.c shoot.c start_task.c Vision.c AngleSynchronize.c super_cap.c super_cap.h
  group hardware
    ../user/hardware/: CAN.c led.c PWM.c imu.c power.c usart.c spi.c usart7.c usart8.c Updata_vsion.c Time.c visual_process.c
    ../user/hardware/delay/: delay.c
    ../user/APP/: FreeRTOS_middleware.c
  group SYSTEM
    ../user/SYSTEM/sys/: sys.c
  group IMU
    ../user/IMU/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6500.c mpu6500reg.h dmpKey.h dmpmap.h
