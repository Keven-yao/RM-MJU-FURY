# Keil uVision project standard.uvprojx, settings and files
target standard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\User\AHRS;..\User\DSP\Include;..\User\FreeRTOS\include;..\User\FreeRTOS\portable;..\User\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\user_lib;..\user\hardware\timer;..\User\APP\Calibrate_Task;..\User\APP\CAN_Receive;..\User\APP\Chassis_Task;..\User\APP\Detect_Task;..\User\APP\FreeRTOS_Middleware;..\User\APP\Gimbal_Task;..\User\APP\INS_Task;..\User\APP\pid;..\User\APP\Remote_Control;..\User\APP\Shoot;..\User\APP\Start_Task;..\User\APP\User_Task;..\user\SYSTEM\sys;..\user\SYSTEM\delay;..\user\APP;..\user\hardware;..\user\APP;..\user\SYSTEM\delay
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_rng.c stm32f4xx_dma.c stm32f4xx_syscfg.c
  group freeRTOS
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group user_lib
    ../user/user_lib/: user_lib.c
  group main
    ../user/: main.c
  group hardware
    ../user/hardware/: CAN.c led.c power.c PWM.c usart.c
    ../user/hardware/timer/: timer.c
  group SYSTEM
    ../user/SYSTEM/sys/: sys.c
  group APP
    ../user/APP/: Chassis.c Control.c feedback.c get_bullet.c gimbal.c help.c shoot.c start_task.c
    ../user/hardware/delay/: delay.c
  group readme
    ../: README.txt
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
